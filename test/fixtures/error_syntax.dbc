VERSION ""


NS_ :

BS_:

BU_:


BO_ not_a_number Bad_Message: 8 Vector__XXX
 SG_ Some_Signal : 0|8@1+ (1,0) [0|255] "" Vector__XXX
